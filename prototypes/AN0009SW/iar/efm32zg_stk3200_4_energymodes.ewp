# IAR project efm32zg_stk3200_4_energymodes.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32ZG222F32 EnergyMicro EFM32ZG222F32
  ICCARM.CCDefines: EFM32ZG222F32; STK3200
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Include; ..\..\..\Device\EnergyMicro\EFM32ZG\Include; ..\..\..\emlib\inc; ..\..\..\kits\common\bsp; ..\..\..\kits\common\drivers; ..\..\..\kits\EFM32ZG_STK3200\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: efm32zg_stk3200_4_energymodes.bin
  ILINK.IlinkOutputFile: efm32zg_stk3200_4_energymodes.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32ZG222F32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32ZG222F32; STK3200
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../Device/EnergyMicro/EFM32ZG/Source/IAR/: startup_efm32zg.s
    ../../../Device/EnergyMicro/EFM32ZG/Source/: system_efm32zg.c
  group emlib
    ../../../emlib/src/: em_cmu.c em_emu.c em_rtc.c
  group Source Files
    ../: 4_energymodes_zg.c
