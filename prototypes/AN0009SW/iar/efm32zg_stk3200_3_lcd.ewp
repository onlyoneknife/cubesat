# IAR project efm32zg_stk3200_3_lcd.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32ZG222F32 EnergyMicro EFM32ZG222F32
  ICCARM.CCDefines: EFM32ZG222F32; STK3200
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Include; ..\..\..\Device\EnergyMicro\EFM32ZG\Include; ..\..\..\emlib\inc; ..\..\..\kits\common\bsp; ..\..\..\kits\common\drivers; ..\..\..\kits\EFM32ZG_STK3200\config; ..\..\..\reptile\glib; ..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: efm32zg_stk3200_3_lcd.bin
  ILINK.IlinkOutputFile: efm32zg_stk3200_3_lcd.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32ZG222F32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32ZG222F32; STK3200
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../Device/EnergyMicro/EFM32ZG/Source/IAR/: startup_efm32zg.s
    ../../../Device/EnergyMicro/EFM32ZG/Source/: system_efm32zg.c
  group drivers
    ../../../kits/common/drivers/: display.c displaypalemlib.c displayls013b7dh03.c textdisplay.c udelay.c
  group emlib
    ../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_int.c em_rtc.c em_system.c em_usart.c
  group Source Files
    ../: 3_lcd_zg.c
