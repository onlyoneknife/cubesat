# IAR project em_gxxx_stk_4_energymodes.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32G890F128 EnergyMicro EFM32G890F128
  ICCARM.CCDefines: EFM32G890F128; STKG8XX
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Include; ..\..\..\Device\EnergyMicro\EFM32G\Include; ..\..\..\emlib\inc; ..\..\..\kits\common\bsp; ..\..\..\kits\common\drivers; ..\..\..\kits\EFM32_Gxxx_STK\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: em_gxxx_stk_4_energymodes.bin
  ILINK.IlinkOutputFile: em_gxxx_stk_4_energymodes.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32G890F128.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32G890F128; STKG8XX
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../Device/EnergyMicro/EFM32G/Source/IAR/: startup_efm32g.s
    ../../../Device/EnergyMicro/EFM32G/Source/: system_efm32g.c
  group drivers
    ../../../kits/common/drivers/: segmentlcd.c
  group emlib
    ../../../emlib/src/: em_assert.c em_system.c em_cmu.c em_emu.c em_gpio.c em_rtc.c em_lcd.c
  group Source Files
    ../: 4_energymodes.c
