# Keil uVision project em_gxxx_dk_4_energymodes.uvproj, settings and files
target em_gxxx_dk_4_energymodes (ARM-ADS)
  device: EFM32G890F128 Energy Micro
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: em_gxxx_dk_4_energymodes
  AfterMake: fromelf.exe --bin --output obj\em_gxxx_dk_4_energymodes.bin obj\em_gxxx_dk_4_energymodes.axf
  c flags: Optim=1 oTime=1
  c define: EFM32G890F128
  c misc: --c99
  c include: ..\;..\..\..\CMSIS\Include;..\..\..\Device\EnergyMicro\EFM32G\Include;..\..\..\emlib\inc;..\..\..\kits\common\bsp;..\..\..\kits\common\drivers;..\..\..\kits\EFM32_Gxxx_DK\config
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../../../Device/EnergyMicro/EFM32G/Source/ARM/: startup_efm32g.s
    ../../../Device/EnergyMicro/EFM32G/Source/: system_efm32g.c
  group drivers
    ../../../kits/common/drivers/: segmentlcd.c
  group emlib
    ../../../emlib/src/: em_assert.c em_system.c em_cmu.c em_emu.c em_gpio.c em_rtc.c em_lcd.c
  group Source Files
    ../EFM32_Gxxx_DK/: 4_energymodes.c
