# Keil uVision project efm32gg_stk3700_4_energymodes.uvproj, settings and files
target efm32gg_stk3700_4_energymodes (ARM-ADS)
  device: EFM32GG990F1024 Energy Micro
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: efm32gg_stk3700_4_energymodes
  AfterMake: fromelf.exe --bin --output obj\efm32gg_stk3700_4_energymodes.bin obj\efm32gg_stk3700_4_energymodes.axf
  c flags: Optim=1 oTime=1
  c define: EFM32GG990F1024 STK3700
  c misc: --c99
  c include: ..\;..\..\..\CMSIS\Include;..\..\..\Device\EnergyMicro\EFM32GG\Include;..\..\..\emlib\inc;..\..\..\kits\common\bsp;..\..\..\kits\common\drivers;..\..\..\kits\EFM32GG_STK3700\config
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../../Device/EnergyMicro/EFM32GG/Source/ARM/: startup_efm32gg.s
    ../../../Device/EnergyMicro/EFM32GG/Source/: system_efm32gg.c
  group drivers
    ../../../kits/common/drivers/: segmentlcd.c
  group emlib
    ../../../emlib/src/: em_assert.c em_system.c em_cmu.c em_emu.c em_gpio.c em_rtc.c em_lcd.c
  group Source Files
    ../: 4_energymodes.c
