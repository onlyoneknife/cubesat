# Keil uVision project efm32tg_stk3300_4_energymodes.uvproj, settings and files
target efm32tg_stk3300_4_energymodes (ARM-ADS)
  device: EFM32TG840F32 Energy Micro
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: efm32tg_stk3300_4_energymodes
  AfterMake: fromelf.exe --bin --output obj\efm32tg_stk3300_4_energymodes.bin obj\efm32tg_stk3300_4_energymodes.axf
  c flags: Optim=1 oTime=1
  c define: EFM32TG840F32 STK3300
  c misc: --c99
  c include: ..\;..\..\..\CMSIS\Include;..\..\..\Device\EnergyMicro\EFM32TG\Include;..\..\..\emlib\inc;..\..\..\kits\common\bsp;..\..\..\kits\common\drivers;..\..\..\kits\EFM32TG_STK3300\config
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../../Device/EnergyMicro/EFM32TG/Source/ARM/: startup_efm32tg.s
    ../../../Device/EnergyMicro/EFM32TG/Source/: system_efm32tg.c
  group drivers
    ../../../kits/common/drivers/: segmentlcd.c
  group emlib
    ../../../emlib/src/: em_assert.c em_system.c em_cmu.c em_emu.c em_gpio.c em_rtc.c em_lcd.c
  group Source Files
    ../: 4_energymodes.c
